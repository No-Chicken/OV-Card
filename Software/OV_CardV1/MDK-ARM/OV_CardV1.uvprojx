# Keil uVision project OV_CardV1.uvprojx, settings and files
target OV_CardV1 (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: OV_CardV1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\BSP\EEPROM;..\BSP\KEY;..\BSP\RC522;..\BSP\Soft_SPI;..\BSP\EPaper\Config;..\BSP\EPaper\e-Paper;..\BSP\EPaper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Application/User/BSP
    ../BSP/EEPROM/: EEPROM.c
    ../BSP/KEY/: key.c
    ../BSP/RC522/: RC522.c
    ../BSP/Soft_SPI/: Soft_SPI.c
  group Application/User/EPaper
    ../BSP/EPaper/: UserGUI.c
    ../BSP/EPaper/e-Paper/: EPD_1in54_V2.c
    ../BSP/EPaper/Config/: DEV_Config.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
